# IAR project sensor.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5418A MSP430F5418A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ; ..\src\; ..\comm\; ..\src\bus\; ..\src\cc2420\; ..\src\sensor\; ..\src\time\; ..\src\rfm98\
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: E:\yjk\file\华煜八方\地磁模块改NBIOT\程序\程序\lnk430f5418Low.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group BC95
    ../src/BC95/: BC95.c mcu_buffer.c
  group comm
    ../comm/: types.h
  group prj_149
    ./: board.c main.c
  group src
    ../src/rfm98/: 24l01.c
  group src/bus
    ../src/bus/: flash.c uart.c
  group src/cc2420
    ../src/cc2420/: cfg.c rf_hal.c
  group src/sensor
    ../src/sensor/: ad.c magentic.c
  group src/time
    ../src/time/: timeslot.c
